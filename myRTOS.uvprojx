# Keil uVision project myRTOS.uvprojx, settings and files
target stm32f4 (6190000::V6.19::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group osKernel
    ./: osKernel.c osKernel.h osKernel.s
  group app
    ./: main.c
  group BSP
    ./: STM32F4_RTOS_BSP.h STM32F4_RTOS_BSP.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
